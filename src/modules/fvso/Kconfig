## src/modules/fvso/Kconfig
```kconfig
menuconfig MODULES_FVSO
    bool "fvso"
    default n
    ---help---
        Enable support for FVSO
```
